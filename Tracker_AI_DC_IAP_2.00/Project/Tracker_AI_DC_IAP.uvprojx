# Keil uVision project Tracker_AI_DC_IAP.uvprojx, settings and files
target Tracker_AI_DC_IAP_V024 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tracker_AI_DC_IAP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output .\bin\Tracker_AI_DC_IAP.bin .\Output\Tracker_AI_DC_IAP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\uCOS-III\uC-LIB;..\uCOS-III\uC-CPU;..\uCOS-III\Source;..\uCOS-III\Ports;..\uCOS-III\Config;..\Main;..\HAL;..\BSP;..\TaskAppendPackage;..\Resource
  memory RVCT4: ROM 0x8002000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group uC/OS-III Source
    ../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Ports
    ../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/CPU
    ../uCOS-III/uC-CPU/: cpu.h cpu_a.asm cpu_core.c cpu_core.h cpu_def.h
  group uC/Config
    ../uCOS-III/Config/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uC/LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group Main
    ../Main/: main.c Init.c Init.h GlobalDefine.h
  group Resource
    ../Resource/: ASProtocol.c ASProtocol.h ProtocolAnalysis.c ProtocolAnalysis.h WorkModeManager.c WorkModeManager.h PowerManagement.c PowerManagement.h AstronomicalAlgorithms.c AstronomicalAlgorithms.h MotorProtection.c MotorProtection.h HWProtocol.c HWProtocol.h
  group HAL
    ../HAL/: AngleSensorHAL.c AngleSensor.c LSM6DS3RegDefs.h ICM20602RegDefs.h AngleSensor.h PVPower.c PVPower.h BatteryPower.c LTC4015RegDefs.h BatteryPower.h MotorControl.c MotorControl.h LEDHAL.c LED.h ModbusFrameHAL.c ModbusFrame.h FlashStorage.h FlashStorageHAL.c ADCSample.c ADCSample.h RTC.c RTC.h TMPSensor.c TMP75RegDefs.h TMPSensor.h HardwareVersion.c HardwareVersion.h BackupRegister.c BackupRegister.h RtcLocalModule.c RtcLocalModule.h
  group BSP
    ../BSP/: IICBSP.c IIC.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
